# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407,__TARGET_FPU_VFP,CONFIG_USB_DWC2_PORT=FS_PORT,USE_USB_FS,CONFIG_DWC2_GD32
  c misc: --no-multibyte-chars
  c include: ..\..\app;..\..\bsp;..\..\libraries\CMSIS\GD\GD32F4xx\Include;..\..\libraries\CMSIS\GD\GD32F4xx;..\..\libraries\GD32F4xx_standard_peripheral\Include;..\..\libraries\CMSIS;..\..\libraries\CMSIS\GD\GD32F4xx\Source\ARM;..\..\board;..\..\libraries\CherryUSB\core;..\..\libraries\CherryUSB\common;..\..\libraries\CherryUSB\class\cdc;..\..\libraries\CherryUSB\class\msc;..\..\libraries\CherryUSB\class\hid
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\project.sct
  group APP
    ../../app/: main.c
    F:/download/SkyStar-GD32F407VET6-DAPLINK/libraries/CherryUSB-0.10.2/demo/: msc_ram_template.c
  group STD_Driver
    ../../libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group STARTUP
    ../../libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group CherryUSB
    ../../libraries/CherryUSB/class/cdc/: usbd_cdc_acm.c
    ../../libraries/CherryUSB/core/: usbd_core.c
    ../../libraries/CherryUSB/port/dwc2/: usb_glue_gd.c usb_dc_dwc2.c
    ../../libraries/CherryUSB/class/msc/: usbd_msc.c
  group CMSIS
    ../../libraries/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Board
    ../../board/: board.c
  group BSP
    ../../bsp/: bsp_led.c bsp_uart.c
  group DOC
    ../../: README.md
software components: CMSIS Driver:USART:Custom 1.0.0
